options:
  parameters:
    author: tom
    generate_options: qt_gui
    id: ASCII_DCS_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: CPO
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: 2*math.pi
    value: '0'
  states: {}
- name: QPSK_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 800e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-fc'
    offset: '0'
    phase: CPO
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_constellation
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*math.pi/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: bypassed}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {state: bypassed}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of all them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Output SYNC preamble once, then repeating message"""

          def __init__(self, message="HELLO"):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Text Message Transmitter',
                  in_sig=None,  # No input signal
                  out_sig=[np.uint8]  # Output unpacked bits
              )
              
              # Preamble: SYNC (32 bits)
              self.preamble_bits = np.array([0,1,0,1,0,0,1,1,  # S
                                              0,1,0,1,1,0,0,1,  # Y
                                              0,1,0,0,1,1,1,0,  # N
                                              0,1,0,0,0,0,1,1], dtype=np.uint8)  # C
              
              # Message: convert string to bits
              self.message_bits = []
              for char in message:
                  ascii_val = ord(char)
                  for i in range(7, -1, -1):  # MSB first
                      self.message_bits.append((ascii_val >> i) & 1)
              self.message_bits = np.array(self.message_bits, dtype=np.uint8)
              
              self.bit_index = 0
              self.chars_saved = 0
              self.max_chars = 100
              
              # Clear files on init
              open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/tx_ascii.txt", "w").close()
              open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/tx_binary.txt", "w").close()

          def work(self, input_items, output_items):
              """Output preamble once, then repeating message (save limited amount)"""
              
              output = output_items[0]
              n_bits = len(output)
              
              text_ascii = ""
              text_binary = ""
              
              for i in range(n_bits):
                  if self.bit_index < len(self.preamble_bits):
                      # Send preamble first
                      output[i] = self.preamble_bits[self.bit_index]
                      bit = self.preamble_bits[self.bit_index]
                  else:
                      # After preamble, loop the message
                      message_offset = (self.bit_index - len(self.preamble_bits)) % len(self.message_bits)
                      output[i] = self.message_bits[message_offset]
                      bit = self.message_bits[message_offset]
                  
                  # Save to file if we haven't hit limit
                  if self.chars_saved < self.max_chars * 8:  # 8 bits per char
                      text_binary += str(int(bit))
                      # Every 8 bits, add the ASCII char
                      if len(text_binary) % 8 == 0:
                          byte_val = int(text_binary[-8:], 2)
                          text_ascii += chr(byte_val)
                          self.chars_saved += 1
                  
                  self.bit_index += 1
              
              # Write files (append mode)
              if text_ascii:
                  with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/tx_ascii.txt", "a") as f:
                      f.write(text_ascii)
              
              if text_binary:
                  with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/tx_binary.txt", "a") as f:
                      f.write(text_binary)
              
              return n_bits
    message: '"Hello"'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Convert unpacked bits to packed bytes, save binary and ASCII versions"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Bits to ASCII',
                  in_sig=[np.uint8],  # Input: unpacked bits
                  out_sig=None  # No output
              )
              self.bit_buffer = []
              self.chars_saved = 0
              self.max_chars = 100

          def work(self, input_items, output_items):
              """Pack bits into bytes and save binary and ASCII versions"""
              bits = input_items[0]
              
              # Stop saving if we've hit the limit
              if self.chars_saved >= self.max_chars:
                  return len(bits)
              
              # Add bits to buffer
              for bit in bits:
                  self.bit_buffer.append(int(bit))
              
              # Process complete bytes (8 bits at a time)
              text_ascii = ""
              text_binary = ""
              while len(self.bit_buffer) >= 8 and self.chars_saved < self.max_chars:
                  byte_bits = self.bit_buffer[:8]
                  self.bit_buffer = self.bit_buffer[8:]
                  
                  # Convert 8 bits to a byte value
                  byte_val = 0
                  for i, b in enumerate(byte_bits):
                      byte_val = (byte_val << 1) | b
                  
                  # ASCII conversion
                  text_ascii += chr(byte_val)
                  
                  # Binary conversion (8 bits as '01010101')
                  text_binary += ''.join([str(int(b)) for b in byte_bits])
                  
                  self.chars_saved += 1
              
              # Write both files
              if text_ascii:
                  with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/tx_ascii.txt", "a") as f:
                      f.write(text_ascii)
              
              if text_binary:
                  with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/tx_binary.txt", "a") as f:
                      f.write(text_binary)
              
              return len(bits)
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Convert unpacked bits to ASCII text, save binary and ASCII versions"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Bits to ASCII',
                  in_sig=[np.uint8],  # Input: unpacked bits
                  out_sig=None  # No output
              )
              self.bit_buffer = []
              self.chars_saved = 0
              self.max_chars = 500

          def work(self, input_items, output_items):
              """Pack bits into bytes and convert to ASCII"""
              bits = input_items[0]
              
              # Stop saving if we've hit the limit
              if self.chars_saved >= self.max_chars:
                  return len(bits)
              
              # Add bits to buffer
              for bit in bits:
                  self.bit_buffer.append(int(bit))
              
              # Process complete bytes (8 bits at a time)
              text_ascii = ""
              text_binary = ""
              while len(self.bit_buffer) >= 8 and self.chars_saved < self.max_chars:
                  byte_bits = self.bit_buffer[:8]
                  self.bit_buffer = self.bit_buffer[8:]
                  
                  # Convert 8 bits to a byte value
                  byte_val = 0
                  for i, b in enumerate(byte_bits):
                      byte_val = (byte_val << 1) | b
                  
                  # ASCII conversion
                  text_ascii += chr(byte_val)
                  
                  # Binary conversion (8 bits as '01010101')
                  text_binary += ''.join([str(int(b)) for b in byte_bits])
                  
                  self.chars_saved += 1
              
              # Write both files
              if text_ascii:
                  with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/rx_ascii.txt", "a") as f:
                      f.write(text_ascii)
              
              if text_binary:
                  with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/rx_binary.txt", "a") as f:
                      f.write(text_binary)
              
              return len(bits)
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Search for SYNC pattern and output aligned bits"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='SYNC Finder',
                  in_sig=[np.uint8],  # Input: unpacked bits
                  out_sig=None  # No output
              )
              self.bit_buffer = []
              self.chars_saved = 0
              self.max_chars = 500
              self.sync_found = False
              self.sync_position = -1
              
              # SYNC pattern: 01010011 01011001 01001110 01000011
              self.sync_pattern = np.array([0,1,0,1,0,0,1,1,
                                             0,1,0,1,1,0,0,1,
                                             0,1,0,0,1,1,1,0,
                                             0,1,0,0,0,0,1,1], dtype=np.uint8)

          def find_sync(self, bits_array):
              """Search for SYNC pattern, return position"""
              sync_len = len(self.sync_pattern)
              for i in range(len(bits_array) - sync_len + 1):
                  if np.array_equal(bits_array[i:i+sync_len], self.sync_pattern):
                      return i
              return -1

          def work(self, input_items, output_items):
              """Find SYNC and save aligned data"""
              bits = input_items[0]
              
              if self.chars_saved >= self.max_chars:
                  return len(bits)
              
              # Add bits to buffer
              for bit in bits:
                  self.bit_buffer.append(int(bit))
              
              # Look for SYNC if not found yet
              if not self.sync_found and len(self.bit_buffer) >= len(self.sync_pattern):
                  bits_array = np.array(self.bit_buffer, dtype=np.uint8)
                  sync_pos = self.find_sync(bits_array)
                  
                  if sync_pos != -1:
                      self.sync_found = True
                      self.sync_position = sync_pos
                      # Write initial marker
                      with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/rx_aligned_ascii.txt", "w") as f:
                          f.write(f"[SYNC FOUND AT BIT {sync_pos}]\n")
                      with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/rx_aligned_binary.txt", "w") as f:
                          f.write(f"[SYNC FOUND AT BIT {sync_pos}]\n")
              
              # Process bytes starting after SYNC
              if self.sync_found:
                  # Start from after SYNC pattern
                  start_idx = self.sync_position + len(self.sync_pattern)
                  
                  text_ascii = ""
                  text_binary = ""
                  
                  i = start_idx
                  while i + 8 <= len(self.bit_buffer) and self.chars_saved < self.max_chars:
                      byte_bits = self.bit_buffer[i:i+8]
                      
                      # Convert to byte
                      byte_val = 0
                      for b in byte_bits:
                          byte_val = (byte_val << 1) | b
                      
                      text_ascii += chr(byte_val)
                      text_binary += ''.join([str(int(b)) for b in byte_bits])
                      
                      self.chars_saved += 1
                      i += 8
                  
                  # Write aligned files
                  if text_ascii:
                      with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/rx_aligned_ascii.txt", "a") as f:
                          f.write(text_ascii)
                  
                  if text_binary:
                      with open("/home/tom/Documents/UofT/UTAT/SDR/Digital_Communication_System/data/rx_aligned_binary.txt", "a") as f:
                          f.write(text_binary)
              
              return len(bits)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: Uncorrected
    label2: Costas Loop
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate / sps
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_signal_filtered
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: input_bits
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: decoded_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_signal_filtered
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: decoded_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: input_bits
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_throttle2_0_0_0_0, '0']
- [blocks_throttle2_0_0_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0_0_0_0, '0', virtual_sink_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_3, '0']
- [blocks_unpack_k_bits_bb_1, '0', epy_block_1, '0']
- [channels_channel_model_0, '0', blocks_multiply_xx_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0, '0']
- [digital_constellation_modulator_0, '0', root_raised_cosine_filter_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [low_pass_filter_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
