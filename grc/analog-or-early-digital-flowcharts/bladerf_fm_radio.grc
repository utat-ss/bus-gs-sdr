options:
  parameters:
    author: Yutong
    copyright: University of Torono Aerospace Team
    generate_options: qt_gui
    id: bladerf_fm_radio
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: int(2.2e9)
  states: {}
- name: listen_frequency
  id: variable_qtgui_range
  parameters:
    label: Listen Frequency
    start: '88'
    step: '0.25'
    stop: '108'
    value: '98.7'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '-1'
    step: '1'
    stop: '60'
    value: '-1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(4e6)
  states: {}
- name: tune_frequency
  id: variable_qtgui_range
  parameters:
    label: Tune Frequency
    start: '88'
    step: '0.25'
    stop: '108'
    value: '98.7'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters: {}
  states: {state: disabled}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate/20
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: (tune_frequency - listen_frequency)*(1e6)
    sample_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/20
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    type: fff
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: (tune_frequency)*int(1e6)
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_1, '0', rational_resampler_xxx_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [soapy_bladerf_source_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
