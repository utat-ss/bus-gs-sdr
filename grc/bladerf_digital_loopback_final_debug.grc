options:
  parameters:
    author: shup-liu
    generate_options: qt_gui
    id: bladerf_digital_loopback
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    comment: |-
      alpha = 0.2
      bandwidth -
    value: '0.2'
  states: {}
- name: constell0
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: constell0_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {state: disabled}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 500e6
    step: 100e6
    stop: 2.5e9
    value: 2.1e9
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      Idk why we need this...
      "Because clocks are not synchronized??"
    start: '-200000'
    step: '100'
    stop: '200000'
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: sps
  id: variable
  parameters:
    comment: sample_per_symbol
    value: '2'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    comment: |-
      AGC3 is better...?

      ... no?
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: scales amplitude
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '1'
    min: '0'
    num_samps: '30000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: offset
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    comment: used en lieu of "pack K bits", see if better...
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 1, 1, 0, 0, 0, 0, 1)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (1+ 1j,)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/shup-liu/Code/FINCH-RF-SDR/grc/wahahaha.mp3
    repeat: 'True'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constell0
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constell0
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constell0
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*math.pi/100
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      ber_align_hier.py  —  BER Align Hier Block
      ===========================================
      A GNU Radio embedded Python block that:
        1. Buffers CAL_SIZE bytes from both TX and RX streams
        2. Cross-correlates (once) to find the bit-lag between them
        3. Locks the lag, applies a delay to the leading stream
        4. Computes BER on a sliding window and emits it as a PMT message

      Ports
      -----
        in0  : TX byte stream  (unpacked bits, 1 bit per byte, MSB in bit 0)
        in1  : RX byte stream  (same format, from demod)
        out0 : message port "ber_out"  — PMT pair  (lag_bits, ber_float)

      Usage in GRC
      ------------
        - Drop in as an "Embedded Python Block"
        - Connect TX source → in0, demod output → in1
        - Connect "ber_out" message port to a Message Debug or your own sink
        - Tune CAL_SIZE and REPORT_EVERY to taste

      Parameters (edit at top of class)
      ----------------------------------
        CAL_SIZE     : bytes per stream used for the one-shot lag calibration (default 4096)
        REPORT_EVERY : emit a BER message every this many bytes after lock  (default 1024)
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Align TX vs RX byte streams via cross-correlation, then report BER."""

          def __init__(self, cal_size=4096, report_every=1024):
              gr.sync_block.__init__(
                  self,
                  name="BER Align",
                  in_sig=[np.uint8, np.uint8],   # in0=TX, in1=RX
                  out_sig=None,                   # no stream output — messages only
              )

              # ---- tuneable parameters ----
              self.CAL_SIZE    = int(cal_size)
              self.REPORT_EVERY = int(report_every)

              # ---- internal state ----
              self._tx_cal   = []          # calibration buffers
              self._rx_cal   = []
              self._locked   = False       # True once lag is found
              self._lag      = 0           # positive = RX leads TX (trim RX front)
                                           # negative = TX leads RX (trim TX front)
              self._delay_buf = []         # holds the "early" stream during the lag gap
              self._errors   = 0
              self._total    = 0
              self._since_report = 0

              # message output port
              self.message_port_register_out(pmt.intern("ber_out"))

          # ------------------------------------------------------------------
          # helpers
          # ------------------------------------------------------------------

          def _to_bits(self, byte_arr):
              """Unpack uint8 array (1 bit/byte, bit in LSB) → float ±0.5 for correlation."""
              bits = (byte_arr & 0x01).astype(np.float32)
              return bits - 0.5   # zero-mean for clean cross-correlation

          def _find_lag(self):
              """
              Cross-correlate TX and RX calibration buffers.
              Returns lag in *bits* (positive = RX is ahead of TX).
              """
              tx = self._to_bits(np.array(self._tx_cal, dtype=np.uint8))
              rx = self._to_bits(np.array(self._rx_cal, dtype=np.uint8))

              # Full cross-correlation
              # scipy fft method is faster for large buffers, but numpy is fine here
              corr = np.correlate(rx, tx, mode='full')

              # Peak index → lag
              # corr[len(tx)-1] corresponds to zero lag
              peak_idx = int(np.argmax(corr))
              lag = peak_idx - (len(tx) - 1)

              print(f"[BER Align] Calibration complete. Lag = {lag} bits "
                    f"({'RX leads' if lag > 0 else 'TX leads' if lag < 0 else 'aligned'})")
              return lag

          def _emit_ber(self, lag):
              ber = self._errors / self._total if self._total > 0 else 0.0
              msg = pmt.cons(
                  pmt.from_long(int(lag)),       # car: lag in bits
                  pmt.from_double(float(ber))    # cdr: BER
              )
              self.message_port_pub(pmt.intern("ber_out"), msg)
              print(f"[BER Align] BER = {ber:.6f}  "
                    f"({self._errors}/{self._total} errors,  lag={lag} bits)")

          # ------------------------------------------------------------------
          # main work function
          # ------------------------------------------------------------------

          def work(self, input_items, output_items):
              tx_in = input_items[0]
              rx_in = input_items[1]
              n     = len(tx_in)

              # ---- Phase 1: Calibration ----------------------------------------
              if not self._locked:
                  self._tx_cal.extend(tx_in.tolist())
                  self._rx_cal.extend(rx_in.tolist())

                  if len(self._tx_cal) >= self.CAL_SIZE:
                      self._tx_cal = self._tx_cal[:self.CAL_SIZE]
                      self._rx_cal = self._rx_cal[:self.CAL_SIZE]
                      self._lag    = self._find_lag()
                      self._locked = True

                      # Pre-fill the delay buffer so we can start comparing immediately.
                      # The stream that arrives FIRST needs to wait for the other to catch up.
                      # lag > 0 → RX is ahead, skip first `lag` RX bits
                      # lag < 0 → TX is ahead, skip first `|lag|` TX bits
                      # (We just discard the offset bytes; they were calibration data anyway.)

                  return n   # consume all input, emit nothing during calibration

              # ---- Phase 2: Locked — compare bit by bit ------------------------
              lag = self._lag

              if lag >= 0:
                  # RX arrived lag bits earlier → trim lag bits off the front of RX
                  # We already consumed cal data so just align within this work call
                  tx_bits = tx_in & 0x01
                  rx_bits = rx_in & 0x01

                  # Apply lag offset within available samples
                  offset = min(lag, n)
                  tx_cmp = tx_bits[: n - offset]
                  rx_cmp = rx_bits[offset: n]
              else:
                  # TX arrived |lag| bits earlier → trim from TX
                  offset  = min(-lag, n)
                  tx_bits = tx_in & 0x01
                  rx_bits = rx_in & 0x01
                  tx_cmp  = tx_bits[offset: n]
                  rx_cmp  = rx_bits[: n - offset]

              # Count bit errors
              if len(tx_cmp) > 0 and len(rx_cmp) > 0:
                  cmp_len = min(len(tx_cmp), len(rx_cmp))
                  self._errors += int(np.sum(tx_cmp[:cmp_len] != rx_cmp[:cmp_len]))
                  self._total  += cmp_len
                  self._since_report += cmp_len

              # Emit BER message periodically
              if self._since_report >= self.REPORT_EVERY:
                  self._emit_ber(self._lag)
                  self._since_report = 0

              return n
    cal_size: '65536'
    comment: Forget about the BER calculations. Could you have two inputs -- byte stream 1 and byte stream 2, and output delay I should add? I will then add the delay to stream 2, and the use the delayed stream 2 and the original stream 1 to calculate the BER (using the inbuilt BER block)
    report_every: '1024'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    name: '"Unpacked data"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {state: disabled}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    comment: |-
      tom's block (?)
      num taps should be 11* num_taps
    decim: '1'
    gain: '1'
    ntaps: int(samp_rate)
    samp_rate: samp_rate
    sym_rate: samp_rate/4
    type: fir_filter_ccf
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: frequency
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_1
  id: soapy_bladerf_source
  parameters:
    center_freq: frequency
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: 2.1e9
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: 2.1e9
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_signal_filtered
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ber_input_signal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ber_output_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_signal_filtered
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ber_input_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: ber_output_signal
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_agc3_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_random_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_repeat_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_repeat_0, '0', soapy_plutosdr_sink_0, '0']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_3, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_1, '0', epy_block_0, '0']
- [blocks_unpack_k_bits_bb_1_0, '0', epy_block_0, '1']
- [blocks_unpacked_to_packed_xx_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_repeat_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_repeat_0, '0']
- [digital_constellation_modulator_0, '0', root_raised_cosine_filter_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, ber_out, qtgui_number_sink_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_1, '0']
- [root_raised_cosine_filter_1, '0', blocks_throttle2_0, '0']
- [soapy_bladerf_source_1, '0', analog_agc3_xx_0, '0']
- [soapy_bladerf_source_1, '0', analog_agc_xx_0, '0']
- [soapy_bladerf_source_1, '0', blocks_multiply_xx_0, '0']
- [soapy_plutosdr_source_0, '0', analog_agc3_xx_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', blocks_unpack_k_bits_bb_1, '0']
- [virtual_source_2, '0', blocks_unpack_k_bits_bb_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
