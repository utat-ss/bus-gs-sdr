options:
  parameters:
    generate_options: qt_gui
    id: FLL_debug
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '500'
    value: '50'
  states: {state: disabled}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    start: '0.001'
    step: '0.001'
    stop: '0.030'
    value: '0.010'
  states: {state: disabled}
- name: msg
  id: variable
  parameters:
    value: '"0001000101011100101001111010011110101011010110001111010101001111011101110110101"'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: qpsk_cons
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 1e6 in hardware
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    comment: 2 seconds of repeated data
    max: '2'
    min: '0'
    num_samps: int(samp_rate*5)
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: ber_async_ber_calculator_0
  id: ber_async_ber_calculator
  parameters:
    sequence: '0001000101011100101001111010011110101011010110001111010101001111011101110110101'
  states: {state: disabled}
- name: ber_async_ber_calculator_1
  id: ber_async_ber_calculator
  parameters:
    sequence: '0001000101011100101001111010011110101011010110001111010101001111011101110110101'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_fll_debug_0704.txt
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: bypassed}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: skips the 00bit
    repeat: 'True'
    type: byte
    vector: (0, 1, 1, 1, 1, 0)
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[int(num) for num in msg]'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_cons
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_cons
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*math.pi/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: |-
      filter size: sps*2+1
      loop bandwidth: 2 * math.pi / sps / 100 ~= 0.003

      Claude: sps*11 + 1
      loop_bw = 0.005 – 0.020
    filter_size: 3*sps+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: '0.011'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Takes care of RRC???
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          Repeating byte source:
            0, 1, 2, ..., 255, 0, 1, ...
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Repeating 0-255 Byte Source",
                  in_sig=None,
                  out_sig=[np.uint8],
              )

              self.index = 0

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)

              out[:] = (self.index + np.arange(n)) % 256
              self.index = (self.index + n) % 256

              return n
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      PILOT_LEN = 256

      def pack_bits_with_offset(bits, bit_offset, bitorder):
          trimmed = bits[bit_offset:]
          n_bytes = len(trimmed) // 8
          if n_bytes == 0:
              return np.array([], dtype=np.uint8)
          usable = trimmed[:n_bytes * 8]
          return np.packbits(usable, bitorder=bitorder)

      def is_increasing_mod256(packed, min_run=16):
          """
          Check if packed bytes look like the repeating 0..255 ramp.
          Returns fraction of consecutive pairs that are +1 mod 256.
          """
          if len(packed) < 2:
              return 0.0
          expected_next = ((packed[:-1].astype(np.uint16) + 1) % 256).astype(np.uint8)
          good = np.sum(packed[1:] == expected_next)
          return good / (len(packed) - 1)

      def find_best_alignment(bits, min_run=16):
          """
          Try all 8 bit offsets x 2 bit orders = 16 combinations.
          Returns (best_bit_offset, best_bitorder, best_byte_phase) or None.
          """
          best = None
          best_score = 0.0

          for bitorder in ['big', 'little']:
              for bit_offset in range(8):
                  packed = pack_bits_with_offset(bits, bit_offset, bitorder)
                  if len(packed) < min_run:
                      continue
                  score = is_increasing_mod256(packed)
                  if score > best_score:
                      # find byte phase: which value does the sequence start at?
                      best_score = score
                      # estimate byte phase from first byte
                      byte_phase = int(packed[0])
                      best = (bit_offset, bitorder, byte_phase, score)

          return best  # None if nothing found


      class blk(gr.sync_block):
          def __init__(self, buffer_size=20000, realign_interval=50000, periodic_realign=True, score_threshold=0.2, stats_reset_interval=1000):
              gr.sync_block.__init__(
                  self,
                  name='BER Calculator',
                  in_sig=[np.uint8],       # unpacked bit stream (0s and 1s)
                  out_sig=[np.float32, np.float32]  # [BER, byte error rate]
              )
              self.buffer_size = buffer_size
              self.realign_interval = realign_interval
              self.periodic_realign = periodic_realign
              self.score_threshold = score_threshold

              self.bit_buffer = np.array([], dtype=np.uint8)

              self.synced = False
              self.bit_offset = 0
              self.bitorder = 'big'
              self.byte_phase = 0         # which value in 0..255 we expect next

              self.total_bits = 0
              self.total_bit_errors = 0
              self.total_bytes = 0
              self.total_byte_errors = 0

              self.print_counter = 0
              self.realign_counter = 0
              self.last_ber = 0.0
              self.last_byter = 0.0

              self.stats_reset_interval = stats_reset_interval

          def try_align(self):
              result = find_best_alignment(self.bit_buffer)
              if result is None:
                  print("[BER] Could not find alignment.")
                  # return False
              bit_offset, bitorder, byte_phase, score = result
              self.bit_offset = bit_offset
              self.bitorder = bitorder
              self.byte_phase = byte_phase
              # consume the bits used for alignment
              self.bit_buffer = self.bit_buffer[bit_offset:]
              print(f"[BER] bit_offset={bit_offset} bitorder={bitorder} byte_phase={byte_phase} score={score:.4f}")

              if score > score_threshold:
                  return True
              else:
                  return False

          def work(self, input_items, output_items):
              bits_in = input_items[0]
              n = len(bits_in)

              self.bit_buffer = np.append(self.bit_buffer, bits_in)

              if not self.synced:
                  if len(self.bit_buffer) >= self.buffer_size:
                      self.synced = self.try_align()
                      if not self.synced:
                          # discard half the buffer and try again next time
                          self.bit_buffer = self.bit_buffer[self.buffer_size // 2:]

              else:
                  # pack available bits into bytes using locked alignment
                  n_bytes = len(self.bit_buffer) // 8
                  if n_bytes > 0:
                      usable = self.bit_buffer[:n_bytes * 8]
                      packed = np.packbits(usable, bitorder=self.bitorder)
                      self.bit_buffer = self.bit_buffer[n_bytes * 8:]

                      # build expected ramp
                      expected = ((self.byte_phase + np.arange(n_bytes)) % PILOT_LEN).astype(np.uint8)
                      self.byte_phase = int((self.byte_phase + n_bytes) % PILOT_LEN)

                      # byte errors
                      byte_errors = int(np.sum(packed != expected))
                      self.total_bytes += n_bytes
                      self.total_byte_errors += byte_errors

                      # bit errors
                      xor = np.bitwise_xor(packed, expected)
                      bit_errors = int(np.sum(np.unpackbits(xor)))
                      self.total_bits += n_bytes * 8
                      self.total_bit_errors += bit_errors

                      self.realign_counter += n_bytes
                      self.print_counter += n_bytes

                      if self.print_counter >= self.stats_reset_interval:
                          self.last_ber = self.total_bit_errors / self.total_bits if self.total_bits else 0.0
                          self.last_byter = self.total_byte_errors / self.total_bytes if self.total_bytes else 0.0
                          print(f"[BER] BER={self.last_ber:.6f}  ByteER={self.last_byter:.6f}  bits={self.total_bits}  bytes={self.total_bytes}")
                          self.print_counter = 0
                          self.total_bits = 0
                          self.total_bit_errors = 0
                          self.total_bytes = 0
                          self.total_byte_errors = 0

                      if self.periodic_realign and self.realign_counter >= self.realign_interval:
                          self.realign_counter = 0
                          self.synced = False
                          self.bit_buffer = np.array([], dtype=np.uint8)
                          print("[BER] Re-aligning...")

              output_items[0][:n] = self.last_ber
              output_items[1][:n] = self.last_byter
              return n
    buffer_size: '20000'
    periodic_realign: 'True'
    realign_interval: '50000'
    score_threshold: '0.2'
    stats_reset_interval: '1000'
  states: {state: disabled}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: '"Pre FLL"'
    label2: '"Post FLL"'
    name: '"pre & post FLL"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    label1: '"pre costas"'
    label2: '"post costas"'
    name: '"Pre&Post Costas Loop"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_3
  id: qtgui_const_sink_x
  parameters:
    name: '"agc"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_4
  id: qtgui_const_sink_x
  parameters:
    name: '"Rx cons"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_5
  id: qtgui_const_sink_x
  parameters:
    name: '"rx signal"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: int(11*sps)
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: center_freq
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: center_freq
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: transmitted_complex_signal
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: complex_rx_signal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: og_signal
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: transmitted_complex_signal
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: og_signal
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: complex_rx_signal
  states: {}

connections:
- [analog_agc3_xx_0, '0', channels_channel_model_0, '0']
- [analog_agc3_xx_0, '0', qtgui_const_sink_x_3, '1']
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [ber_async_ber_calculator_0, '0', qtgui_time_sink_x_0, '0']
- [ber_async_ber_calculator_0, '1', qtgui_time_sink_x_0, '1']
- [ber_async_ber_calculator_1, '0', qtgui_number_sink_0, '0']
- [ber_async_ber_calculator_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [ber_async_ber_calculator_1, '1', qtgui_time_sink_x_0_0_0, '1']
- [blocks_char_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_pack_k_bits_bb_1, '0', digital_constellation_modulator_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle2_0, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_throttle2_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', ber_async_ber_calculator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', ber_async_ber_calculator_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_1, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_1, '0', blocks_throttle2_0, '0']
- [channels_channel_model_0, '0', filter_fft_rrc_filter_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_decoder_cb_1, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_4, '0']
- [digital_constellation_modulator_0, '0', soapy_plutosdr_sink_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '1']
- [digital_costas_loop_cc_0, '0', virtual_sink_1, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_1, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_1, '1', qtgui_time_sink_x_0_0, '1']
- [filter_fft_rrc_filter_0, '0', digital_fll_band_edge_cc_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_const_sink_x_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [soapy_bladerf_source_0, '0', analog_agc3_xx_0, '0']
- [soapy_bladerf_source_0, '0', channels_channel_model_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_const_sink_x_3, '0']
- [soapy_bladerf_source_0, '0', qtgui_const_sink_x_5, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
