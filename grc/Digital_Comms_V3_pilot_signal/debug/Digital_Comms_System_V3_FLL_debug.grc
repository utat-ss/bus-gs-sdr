options:
  parameters:
    author: tom
    generate_options: qt_gui
    id: backup
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: QPSK_constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: QPSK_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {state: disabled}
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1000e6
  states: {}
- name: fc
  id: variable
  parameters:
    value: '200000'
  states: {state: disabled}
- name: noise_frequency_offset
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '0.2'
    value: '0'
  states: {}
- name: noise_timing_offset
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.0001'
    stop: '1.1'
    value: '1'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      was 800k
      not the problem though. depends on the required symbol rate
    value: 600e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    comment: Up the attack and decay rates when we do real life testing
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    comment: |-
      instead of this, have a set pilor signal?
      Also: Pluto -> bladeRF and bladeRF->Pluto
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ber_src
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    comment: |-
      run 
      python3 V3_analyze_pilot_bitstream.py 
      to analyze results

      ==> i.e., we do the bit->byte conversion inside the python file. 
      The python file takes in a file containing the bit stream received, 
      and handles the alignment and the BER calculations. 

      ==> I am assuming that the GNU radio blocks works, but this block is weird. 
      Idk if that's fair tbh. (Is this a firmware issue, actually...?)
    file: pilot_rx_bits.txt
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: skips 1 second of data
    num_items: int(samp_rate)
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: bypassed}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_2
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: noise_timing_offset
    freq_offset: noise_frequency_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_constellation
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_constellation
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_constellation
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*math.pi/100
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*math.pi/100
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*8+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: (2 * math.pi / sps / 100)*1e2
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      PILOT_LEN = 256

      def pack_bits_with_offset(bits, bit_offset, bitorder):
          trimmed = bits[bit_offset:]
          n_bytes = len(trimmed) // 8
          if n_bytes == 0:
              return np.array([], dtype=np.uint8)
          usable = trimmed[:n_bytes * 8]
          return np.packbits(usable, bitorder=bitorder)

      def is_increasing_mod256(packed, min_run=16):
          if len(packed) < 2:
              return 0.0
          expected_next = ((packed[:-1].astype(np.uint16) + 1) % 256).astype(np.uint8)
          good = np.sum(packed[1:] == expected_next)
          return good / (len(packed) - 1)

      def find_best_alignment(bits, min_run=16):
          best = None
          best_score = 0.0
          for bitorder in ['big', 'little']:
              for bit_offset in range(8):
                  packed = pack_bits_with_offset(bits, bit_offset, bitorder)
                  if len(packed) < min_run:
                      continue
                  score = is_increasing_mod256(packed)
                  if score > best_score:
                      best_score = score
                      byte_phase = int(packed[0])
                      best = (bit_offset, bitorder, byte_phase, score)
          return best


      class blk(gr.sync_block):
          def __init__(self, buffer_size=20000, realign_interval=50000, periodic_realign=True, score_threshold=0.8, stats_reset_interval=1000):
              gr.sync_block.__init__(
                  self,
                  name='BER Calculator',
                  in_sig=[np.uint8],
                  out_sig=[np.float32, np.float32]  # [BER, byte error rate]
              )
              self.buffer_size = buffer_size
              self.realign_interval = realign_interval
              self.periodic_realign = periodic_realign
              self.score_threshold = score_threshold
              self.stats_reset_interval = stats_reset_interval

              self.bit_buffer = np.array([], dtype=np.uint8)

              self.synced = False
              self.bit_offset = 0
              self.bitorder = 'big'
              self.byte_phase = 0

              self.total_bits = 0
              self.total_bit_errors = 0
              self.total_bytes = 0
              self.total_byte_errors = 0

              self.print_counter = 0
              self.realign_counter = 0
              self.last_ber = 0.0
              self.last_byter = 0.0

          def try_align(self):
              result = find_best_alignment(self.bit_buffer)
              if result is None:
                  print("[BER] Could not find alignment.")
                  return False

              bit_offset, bitorder, byte_phase, score = result

              # Always apply the best-effort alignment regardless of score
              self.bit_offset = bit_offset
              self.bitorder = bitorder
              self.byte_phase = byte_phase
              self.bit_buffer = self.bit_buffer[bit_offset:]

              if score >= self.score_threshold:
                  print(f"[BER] Locked. bit_offset={bit_offset} bitorder={bitorder} byte_phase={byte_phase} score={score:.4f}")
                  return True  # full lock — stop retrying alignment
              else:
                  print(f"[BER] Best-effort alignment. bit_offset={bit_offset} bitorder={bitorder} byte_phase={byte_phase} score={score:.4f} (below threshold, will keep retrying)")
                  return False  # not locked — keep retrying, but still compute BER

          def _compute_ber(self):
              n_bytes = len(self.bit_buffer) // 8
              if n_bytes == 0:
                  return

              usable = self.bit_buffer[:n_bytes * 8]
              packed = np.packbits(usable, bitorder=self.bitorder)
              self.bit_buffer = self.bit_buffer[n_bytes * 8:]

              expected = ((self.byte_phase + np.arange(n_bytes)) % PILOT_LEN).astype(np.uint8)
              self.byte_phase = int((self.byte_phase + n_bytes) % PILOT_LEN)

              byte_errors = int(np.sum(packed != expected))
              self.total_bytes += n_bytes
              self.total_byte_errors += byte_errors

              xor = np.bitwise_xor(packed, expected)
              bit_errors = int(np.sum(np.unpackbits(xor)))
              self.total_bits += n_bytes * 8
              self.total_bit_errors += bit_errors

              self.realign_counter += n_bytes
              self.print_counter += n_bytes

              if self.print_counter >= self.stats_reset_interval:
                  self.last_ber = self.total_bit_errors / self.total_bits if self.total_bits else 0.0
                  self.last_byter = self.total_byte_errors / self.total_bytes if self.total_bytes else 0.0
                  locked_str = "LOCKED" if self.synced else "best-effort"
                  print(f"[BER] [{locked_str}] BER={self.last_ber:.6f}  ByteER={self.last_byter:.6f}  bits={self.total_bits}  bytes={self.total_bytes}")
                  self.print_counter = 0
                  self.total_bits = 0
                  self.total_bit_errors = 0
                  self.total_bytes = 0
                  self.total_byte_errors = 0

          def work(self, input_items, output_items):
              bits_in = input_items[0]
              n = len(bits_in)

              self.bit_buffer = np.append(self.bit_buffer, bits_in)

              if not self.synced:
                  if len(self.bit_buffer) >= self.buffer_size:
                      self.synced = self.try_align()
                      if not self.synced:
                          # Not locked but still compute BER with best-effort alignment,
                          # then discard half the buffer and re-search next time
                          self._compute_ber()
                          self.bit_buffer = self.bit_buffer[self.buffer_size // 2:]
              else:
                  self._compute_ber()

                  if self.periodic_realign and self.realign_counter >= self.realign_interval:
                      self.realign_counter = 0
                      self.synced = False
                      self.bit_buffer = np.array([], dtype=np.uint8)
                      print("[BER] Re-aligning...")

              output_items[0][:n] = self.last_ber
              output_items[1][:n] = self.last_byter
              return n
    buffer_size: '20000'
    periodic_realign: 'True'
    realign_interval: '50000'
    score_threshold: '0.8'
    stats_reset_interval: '1000'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          Repeating byte source:
            0, 1, 2, ..., 255, 0, 1, ...
          """

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="Repeating 0-255 Byte Source",
                  in_sig=None,
                  out_sig=[np.uint8],
              )

              self.index = 0

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)

              out[:] = (self.index + np.arange(n)) % 256
              self.index = (self.index + n) % 256

              return n
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from collections import deque


      class blk(gr.sync_block):
          """
          Real-time BER calculator for repeated byte pilot:

              0, 1, 2, ..., 255, 0, 1, 2, ...

          BUT input is an unpacked bit stream:

              in0: uint8 stream, values 0 or 1
                   one bit per byte, i.e. GNU Radio "purple" byte stream

          Output:
              out0: float32 BER estimate

          This block does NOT need a TX input.
          It regenerates the expected 0..255 pilot internally, unpacks it into bits,
          finds the bit-level phase offset, then compares bit-by-bit.

          bitorder:
              "big"    = MSB first, matches np.unpackbits(..., bitorder="big")
              "little" = LSB first
              "auto"   = try both during sync and use the better one
          """

          def __init__(
              self,
              sync_buffer_size=4096,
              report_every=8000,
              window_size=80000,
              realign_interval=200000,
              periodic_realign=True,
              bitorder="auto",
          ):
              gr.sync_block.__init__(
                  self,
                  name="Pilot BER Calculator Bits 0-255",
                  in_sig=[np.uint8],
                  out_sig=[np.float32],
              )

              self.sync_buffer_size = int(sync_buffer_size)
              self.report_every = int(report_every)
              self.window_size = int(window_size)
              self.realign_interval = int(realign_interval)
              self.periodic_realign = bool(periodic_realign)
              self.bitorder = str(bitorder)

              if self.sync_buffer_size <= 0:
                  raise ValueError("sync_buffer_size must be positive")

              if self.bitorder not in ["big", "little", "auto"]:
                  raise ValueError('bitorder must be "big", "little", or "auto"')

              # Byte pilot: 0, 1, 2, ..., 255
              self.byte_pilot = np.arange(256, dtype=np.uint8)

              # Bit pilots. Each has length 256 * 8 = 2048 bits.
              self.bit_pilots = {
                  "big": np.unpackbits(self.byte_pilot, bitorder="big").astype(np.uint8),
                  "little": np.unpackbits(self.byte_pilot, bitorder="little").astype(np.uint8),
              }

              self.active_bitorder = None
              self.pilot_bits = None
              self.pilot_len_bits = None

              self.rx_buffer = np.array([], dtype=np.uint8)

              self.synced = False
              self.pilot_bit_index = 0
              self.last_ber = 0.0

              self.bits_since_report = 0
              self.bits_since_realign = 0

              self.window = deque()
              self.window_error_sum = 0
              self.window_bit_sum = 0

          def make_expected_bits(self, start_index, n):
              positions = (start_index + np.arange(n)) % self.pilot_len_bits
              return self.pilot_bits[positions]

          def find_pilot_offset_for_order(self, rx, order):
              """
              Try all bit offsets inside one full pilot period.

              Returns:
                  best_offset, best_errors
              """
              pilot = self.bit_pilots[order]
              period = len(pilot)

              best_offset = 0
              best_errors = None

              # Try all 2048 possible bit-level offsets
              for offset in range(period):
                  positions = (offset + np.arange(len(rx))) % period
                  expected = pilot[positions]

                  errors = int(np.sum(rx != expected))

                  if best_errors is None or errors < best_errors:
                      best_errors = errors
                      best_offset = offset

              return best_offset, best_errors

          def find_pilot_offset(self, rx):
              """
              Finds:
                1. bit order, if bitorder="auto"
                2. bit offset within the 2048-bit repeated pilot
              """
              rx = rx & 0x01

              if self.bitorder == "auto":
                  orders_to_try = ["big", "little"]
              else:
                  orders_to_try = [self.bitorder]

              best_order = None
              best_offset = None
              best_errors = None

              for order in orders_to_try:
                  offset, errors = self.find_pilot_offset_for_order(rx, order)

                  if best_errors is None or errors < best_errors:
                      best_errors = errors
                      best_offset = offset
                      best_order = order

              self.active_bitorder = best_order
              self.pilot_bits = self.bit_pilots[best_order]
              self.pilot_len_bits = len(self.pilot_bits)

              sync_ber = best_errors / len(rx)

              print(
                  f"[Pilot BER Bits] Sync search: "
                  f"bitorder={best_order}, "
                  f"best bit offset={best_offset}, "
                  f"sync BER={sync_ber:.6f}"
              )

              return best_offset

          def add_window_result(self, errors, bits):
              self.window.append((int(errors), int(bits)))
              self.window_error_sum += int(errors)
              self.window_bit_sum += int(bits)

              while self.window_bit_sum > self.window_size and len(self.window) > 1:
                  old_errors, old_bits = self.window.popleft()
                  self.window_error_sum -= old_errors
                  self.window_bit_sum -= old_bits

          def current_window_ber(self):
              if self.window_bit_sum == 0:
                  return 0.0
              return self.window_error_sum / self.window_bit_sum

          def process_rx_bits(self, rx_bits):
              n = len(rx_bits)
              if n == 0:
                  return

              rx_bits = rx_bits & 0x01
              expected = self.make_expected_bits(self.pilot_bit_index, n)

              errors = int(np.sum(rx_bits != expected))
              bits = n

              self.add_window_result(errors, bits)

              self.pilot_bit_index = (self.pilot_bit_index + n) % self.pilot_len_bits

              self.bits_since_report += bits
              self.bits_since_realign += bits

              if self.bits_since_report >= self.report_every:
                  self.last_ber = self.current_window_ber()
                  print(
                      f"[Pilot BER Bits] BER = {self.last_ber:.6f}, "
                      f"bitorder={self.active_bitorder}, "
                      f"pilot_bit_index={self.pilot_bit_index}, "
                      f"window={self.window_error_sum}/{self.window_bit_sum} bits"
                  )
                  self.bits_since_report = 0

          def reset_sync(self):
              self.synced = False
              self.rx_buffer = np.array([], dtype=np.uint8)
              self.bits_since_realign = 0
              print("[Pilot BER Bits] Re-aligning...")

          def work(self, input_items, output_items):
              rx_in = np.asarray(input_items[0], dtype=np.uint8)
              out = output_items[0]
              n = len(rx_in)

              # Sanity warning, sampled lightly
              if n > 0:
                  sample = rx_in[:min(n, 1024)]
                  unique = np.unique(sample)
                  if not np.all((unique == 0) | (unique == 1)):
                      print(
                          "[Pilot BER Bits WARNING] Input is not purely 0/1. "
                          f"Unique sample values: {unique[:20]}"
                      )

              if not self.synced:
                  self.rx_buffer = np.concatenate((self.rx_buffer, (rx_in & 0x01).copy()))

                  if len(self.rx_buffer) >= self.sync_buffer_size:
                      sync_rx = self.rx_buffer[:self.sync_buffer_size]

                      offset = self.find_pilot_offset(sync_rx)

                      self.synced = True
                      self.pilot_bit_index = offset

                      print(
                          f"[Pilot BER Bits] Initial lock: "
                          f"rx_buffer[0] aligned to pilot bit {offset} "
                          f"using bitorder={self.active_bitorder}"
                      )

                      # Process all buffered samples, including sync buffer
                      buffered = self.rx_buffer
                      self.rx_buffer = np.array([], dtype=np.uint8)
                      self.process_rx_bits(buffered)

              else:
                  self.process_rx_bits(rx_in)

                  if self.periodic_realign and self.bits_since_realign >= self.realign_interval:
                      self.reset_sync()

              out[:] = self.last_ber
              return n
    bitorder: '"auto"'
    periodic_realign: 'True'
    realign_interval: '200000'
    report_every: 8000*2
    sync_buffer_size: '4096'
    window_size: '80000'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import csv
      import os
      import time
      from datetime import datetime

      CSV_FILE = "V3_noise_vs_ber.csv"
      LOG_INTERVAL = 0.8  # seconds between each periodic snapshot

      class blk(gr.sync_block):
          """
          Records BER vs noise parameters to a CSV file periodically.
          Every LOG_INTERVAL seconds, snapshots the current parameters and BER.

          Inputs:
              in0: float32 BER estimate (from BER Calculator block)

          Parameters:
              noise_voltage:       TX noise voltage
              noise_freq_offset:   frequency offset applied to noise
              noise_timing_offset: timing offset applied to noise
          """

          def __init__(self, noise_voltage=0.0, noise_freq_offset=0.0, noise_timing_offset=0.0):
              gr.sync_block.__init__(
                  self,
                  name="BER vs Noise Logger",
                  in_sig=[np.float32],
                  out_sig=None,
              )

              self.noise_voltage       = noise_voltage
              self.noise_freq_offset   = noise_freq_offset
              self.noise_timing_offset = noise_timing_offset

              self.last_log_time = time.time()

              self._init_csv()

          def _init_csv(self):
              file_exists = os.path.isfile(CSV_FILE)
              with open(CSV_FILE, "a", newline="") as f:
                  writer = csv.writer(f)
                  if not file_exists:
                      writer.writerow([
                          "timestamp",
                          "noise_voltage",
                          "noise_freq_offset",
                          "noise_timing_offset",
                          "ber",
                      ])

          def _record(self, ber):
              timestamp = datetime.now().strftime("%Y-%m-%d %H:%M:%S.%f")[:-3]
              with open(CSV_FILE, "a", newline="") as f:
                  writer = csv.writer(f)
                  writer.writerow([
                      timestamp,
                      self.noise_voltage,
                      self.noise_freq_offset,
                      self.noise_timing_offset,
                      f"{ber:.8f}",
                  ])
              print(f"[BER Logger] Recorded: voltage={self.noise_voltage} "
                    f"freq_offset={self.noise_freq_offset} "
                    f"timing_offset={self.noise_timing_offset} "
                    f"BER={ber:.8f}")

          def work(self, input_items, output_items):
              ber_in = input_items[0]
              n = len(ber_in)

              now = time.time()
              if now - self.last_log_time >= LOG_INTERVAL:
                  current_ber = float(np.mean(ber_in))
                  self._record(current_ber)
                  self.last_log_time = now

              return n
    noise_freq_offset: noise_frequency_offset
    noise_timing_offset: noise_timing_offset
    noise_voltage: noise_voltage
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      sps = 1 samp_rate = bandwidth
      samp_rate / sps ~= bandwidth

      Bandwith has to do with "squareness" of wave and samp_rate/sps

      shaping is controlled by alpha

      min(BW) = sps

      BW = symbol_rate*(1+alpha)
    cutoff_freq: samp_rate/sps/2*(1+alpha)*2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/sps/2*(1+alpha)*0.5
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: With FLL, Before Costas Loop
    label2: With FLL, After Costas Loop
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    name: '"Without FLL"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    name: '"With FLL"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0.5'
    min: '0'
    name: '"bit ER"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0.5'
    min: '0'
    name: '"byte ER"'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"transmitted signal"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: BER
    ymin: '-0.001'
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate / sps
    type: fir_filter_ccf
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: center_freq
    gain: '17'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: center_freq
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: center_freq
    gain: '68'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0_0
  id: soapy_plutosdr_source
  parameters:
    agc: 'True'
    center_freq: center_freq
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_signal_filtered
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: decoded_signal
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: decoded_signal
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: test
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_signal_filtered
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: decoded_signal
  states: {state: disabled}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: test
  states: {state: disabled}

connections:
- [analog_agc3_xx_0, '0', low_pass_filter_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_throttle2_0_0_0_0, '0']
- [blocks_skiphead_0, '0', blocks_file_sink_1, '0']
- [blocks_skiphead_0, '0', epy_block_0, '0']
- [blocks_throttle2_0_0_0_0, '0', blocks_unpack_k_bits_bb_2, '0']
- [blocks_throttle2_0_0_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_skiphead_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_2, '0']
- [blocks_unpack_k_bits_bb_2, '0', blocks_file_sink_0, '0']
- [channels_channel_model_0, '0', analog_agc3_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', virtual_sink_1_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', soapy_bladerf_sink_0, '0']
- [digital_constellation_modulator_0, '0', soapy_plutosdr_sink_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_2, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_1, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_2, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_1, '0']
- [epy_block_0, '0', epy_block_3, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_0, '0']
- [epy_block_1, '0', blocks_throttle2_0_0_0_0, '0']
- [epy_block_2, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [soapy_bladerf_source_0, '0', channels_channel_model_0, '0']
- [soapy_plutosdr_source_0_0, '0', channels_channel_model_0, '0']
- [virtual_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0_0, '0']
- [virtual_source_1, '0', digital_diff_decoder_bb_0, '0']
- [virtual_source_3, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
