options:
  parameters:
    generate_options: qt_gui
    id: audio_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: adjust
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '-100000'
    step: '1'
    stop: '300000'
    value: '-6000'
  states: {}
- name: freq_rx
  id: variable_qtgui_range
  parameters:
    label: Receiving Freq
    start: 1.96e9
    step: 0.002e9
    stop: 1.97e9
    value: 1.965787e9
  states: {}
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    start: '-int(samp_rate/2)'
    step: '1'
    stop: int(samp_rate/2)
    value: '200000'
    widget: counter
  states: {}
- name: freq_shift_1
  id: variable_qtgui_range
  parameters:
    start: '-int(samp_rate/2)'
    step: '1'
    stop: int(samp_rate/2)
    value: '200000'
    widget: counter
  states: {}
- name: freq_tx
  id: variable_qtgui_range
  parameters:
    label: Transmitting Freq
    start: 1.96e9
    step: 0.002e9
    stop: 1.97e9
    value: 1.965787e9
  states: {}
- name: index
  id: variable_qtgui_range
  parameters:
    label: Select Index
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: msg
  id: variable
  parameters:
    value: '[1,2,3,4,5,6,7]'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: 200e3
    widget: slider
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain Pluto
    start: '0'
    step: '0.25'
    stop: '71'
    value: '0'
  states: {}
- name: rx_gain_b
  id: variable_qtgui_range
  parameters:
    label: Rx Gain Bladerf
    start: '-1'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(800e3)
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain Pluto
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '0'
  states: {}
- name: tx_gain_b
  id: variable_qtgui_range
  parameters:
    label: Tx Gain Bladerf
    start: '17'
    step: '1'
    stop: '73'
    value: '20'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 2.5e3
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 2.5e3
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(48e3)
    fh: '-1'
    max_dev: '2500'
    quad_rate: int(48e3)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: int(freq_shift)
    sample_rate: samp_rate
  states: {state: bypassed}
- name: blocks_freqshift_cc_0_1
  id: blocks_freqshift_cc
  parameters:
    freq: int(freq_shift)+adjust
    sample_rate: samp_rate
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: index
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: received_wahaha.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/shaunaliu/Documents/FINCH-RF-SDR/grc/analog-audio-flowcharts/wahahaha.mp3
    repeat: 'True'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq_rx + freq_shift
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (3e3)*2
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: (1e3)*2
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"wav"'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq_rx
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq_rx
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq_tx
    fftsize: '1024'
    name: '"tx"'
    rate: '5'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: freq_rx
    gain: '40.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: freq_tx
    gain: '60.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: freq_rx
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://0.0.0.0:5555
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_nbfm_rx_0, '0', blocks_selector_0, '1']
- [analog_nbfm_rx_0, '0', blocks_wavfile_sink_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_number_sink_0, '0']
- [analog_nbfm_rx_0, '0', zeromq_push_sink_0, '0']
- [analog_nbfm_rx_0_0, '0', blocks_selector_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_nbfm_rx_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', qtgui_sink_x_0_0_0_0_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_freqshift_cc_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_selector_0, '0', zeromq_push_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1_0, '0']
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', soapy_plutosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_1_0, '0', analog_simple_squelch_cc_0_0, '0']
- [soapy_bladerf_source_0, '0', blocks_freqshift_cc_0, '0']
- [soapy_plutosdr_source_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
