options:
  parameters:
    generate_options: qt_gui
    id: bladerf_audio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(44.1e3)
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(50e3)
    max_dev: 5e3
    quad_rate: int(10e6)
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\UofT\UofT_ECE_Class\ECE 216\labs\lab1\lab1\guitar.wav
    repeat: 'True'
  states: {state: disabled}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://10.0.1.165:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [zeromq_pull_source_0, '0', analog_nbfm_rx_0, '0']
- [zeromq_pull_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
