options:
  parameters:
    author: yutong
    generate_options: qt_gui
    id: audio_pluto_server
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48000)
  states: {}
- name: freq_rx
  id: variable_qtgui_range
  parameters:
    label: Receiving Freq
    start: '432000000'
    step: '1'
    stop: '436000000'
    value: '433720000'
  states: {}
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    start: '-int(samp_rate/2)'
    step: '1'
    stop: int(samp_rate/2)
    value: '200000'
    widget: counter
  states: {}
- name: freq_shift_1
  id: variable_qtgui_range
  parameters:
    start: '-int(samp_rate/2)'
    step: '1'
    stop: int(samp_rate/2)
    value: '200000'
    widget: counter
  states: {}
- name: freq_tx
  id: variable_qtgui_range
  parameters:
    label: Transmitting Freq
    start: '432000000'
    step: '1'
    stop: '436000000'
    value: '433720000'
  states: {}
- name: msg
  id: variable
  parameters:
    value: '[1,2,3,4,5,6,7]'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: 200e3
    widget: slider
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain Pluto
    start: '0'
    step: '0.25'
    stop: '71'
    value: '0'
  states: {}
- name: rx_gain_b
  id: variable_qtgui_range
  parameters:
    label: Rx Gain Bladerf
    start: '-1'
    step: '1'
    stop: '60'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain Pluto
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '0'
  states: {}
- name: tx_gain_b
  id: variable_qtgui_range
  parameters:
    label: Tx Gain Bladerf
    start: '17'
    step: '1'
    stop: '73'
    value: '20'
  states: {}
- name: variable_constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 2.5e3
    quad_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1'
    max_dev: '2500'
    quad_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_threshold
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: int(freq_shift)
    sample_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: guitar.mp3
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 89.75-tx_gain
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq_rx
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq_rx + freq_shift
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: note_1
  id: note
  parameters:
    note: Please connect the pluto RX and TX with attenuator
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq_rx
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq_tx
    fftsize: '1024'
    name: '"tx"'
    rate: '5'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '125'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: test
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: test
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://0.0.0.0:5555
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_nbfm_rx_0, '0', zeromq_push_sink_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_1, '0', analog_simple_squelch_cc_0, '0']
- [virtual_source_0, '0', blocks_freqshift_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
