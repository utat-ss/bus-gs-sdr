options:
  parameters:
    author: Yutong Xin
    generate_options: qt_gui
    id: pluto_loopback_srs4
    output_language: python
    title: Pluto Loopback SRS4
  states: {}

blocks:
- name: freq_rx
  id: variable
  parameters:
    value: '433720000'
  states: {}
- name: freq_shift
  id: variable
  parameters:
    value: '6000'
  states: {}
- name: freq_tx
  id: variable
  parameters:
    value: '433920000'
  states: {}
- name: mod_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: msg
  id: variable
  parameters:
    value: '[1,2,3,4,5,6,7]'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    start: '-samp_rate/2'
    step: samp_rate/100
    stop: samp_rate/2
    value: 200e3
    widget: slider
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.25'
    stop: '71'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '0'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-int(offset)'
    sample_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(msg), msg))
    period: '500'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 89.75-tx_gain
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '435000000'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: 435000000 - int(offset)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '435000000'
    fftsize: '1024'
    rate: '5'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '435000000'
    fftsize: '1024'
    name: '"tx"'
    rate: '5'
    type: complex
  states: {}
- name: satlab_srs4_rx_0_0
  id: satlab_srs4_rx
  parameters:
    auth: 'False'
    cc: 'True'
    constellation: QPSK
    crc: 'True'
    decrypt: 'False'
    idnum: '0'
    key: '"\x00" * 32'
    rand: 'True'
    rate: int(100e3)
    rolloff: '0.2'
    rs: 'True'
    samp_rate: samp_rate
    size: '217'
  states: {}
- name: satlab_srs4_tx_0
  id: satlab_srs4_tx
  parameters:
    auth: 'False'
    cc: 'True'
    constellation: QPSK
    crc: 'True'
    encrypt: 'False'
    idleframes: '10000'
    idnum: '0'
    key: '"\x00" * 32'
    max_in_flight: '100'
    rand: 'True'
    rate: int(100e3)
    rolloff: '0.2'
    rs: 'True'
    samp_rate: samp_rate
    size: '217'
  states: {}

connections:
- [blocks_freqshift_cc_0, '0', satlab_srs4_rx_0_0, '0']
- [blocks_message_strobe_0, strobe, satlab_srs4_tx_0, csp_in]
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0_0, '0']
- [satlab_srs4_rx_0_0, csp_out, blocks_message_debug_0, log]
- [satlab_srs4_tx_0, '0', iio_pluto_sink_0, '0']
- [satlab_srs4_tx_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
